# Keil uVision project STM32F0_REG.uvprojx, settings and files
target STM32F0_REG (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F0_REG +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\AppLayer;.\DriverLayer;.\HalLayer;.\ProtocolLayer;.\Library;.\SysDriver\CMSIS;.\SysDriver\inc;.\SysDriver;.\Debug;.\Test;.\Library\NFC_LIB\ISO14443A;.\Library\NFC_LIB\ISO14443B;.\Library\NFC_LIB\ISO15693
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group AppLayer
    ./AppLayer/: main.c reg_record.c reg_table.c device_config.c uart_mode.c uart_protocol_func.c parameter_mg.c card_sender.c
  group Library
    ./Library/: list.c des.c card_encrypt.c
    ./Library/NFC_LIB/ISO14443A/: lib_iso14443Apcd.c
    ./Library/NFC_LIB/ISO14443B/: lib_iso14443Bpcd.c
    ./Library/NFC_LIB/ISO15693/: lib_iso15693pcd.c
  group ProtocolLayer
    ./ProtocolLayer/: com_protocol.c hal_com.c mac_com.c
  group HalLayer
    ./HalLayer/: hal_timer.c hal_com_func.c hal_fm17x2.c hal_ctrl_io.c
  group DriverLayer
    ./DriverLayer/: timer_drv.c timer_set.c timer_rtc.c wdg_drv.c flash_drv.c uart_drv.c spi_drv.c beep_drv.c card_read_drv.c card_rw_drv.c fm17x2_drv.c ctrl_io_drv.c led_drv.c
  group SysDriver
    ./SysDriver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ./SysDriver/: stm32f0xx_it.c system_stm32f0xx.c startup_stm32f030.s
  group Debug
    ./Debug/: debug.c hal_debug.c
  group Test
    ./Test/: debug_device_config.c debug_card_drv.c debug_timer_drv.c debug_reg_table.c debug_reg_record.c debug_flash.c debug_example.c
